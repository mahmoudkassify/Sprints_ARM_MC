# Keil uVision project Tasks_TivaC.uvprojx, settings and files
target IntCtrl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FirstProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Platforms\tm4c123gh6pm;..\..\Src\Common;..\..\Src\Config;..\..\Src\Mcal;..\..\Src\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ../../Src/Mcal/: McuDriver.c IntCtrl.c WDTDriver.c Timer.c
  group App
    ../../Src/App/IntCtrl/: IntCtrl_main.c
    ../../Src/App/MCU_Driver/: MCU_Driver_main.c
    ../../Src/App/WDT_Driver/: WDT_Driver_main.c
    ../../Src/App/Timer_Driver/: Timer_Driver_main.c
  group Config
    ../../Src/Config/: McuDriver_Cfg.h McuDriver_Lcfg.c IntCtrl_Cfg.h IntCtrl_Lcfg.c WDTDriver_Lcfg.c WDTDriver_cfg.h Timer_cfg.h Timer_Lcfg.c
  group Common
    ../../Src/Common/: Cpu_Driver.c
target MCU_Driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: FirstProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target WDT_Driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: FirstProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Timer_Driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: FirstProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
